# Keil uVision project STSW-L9961BMS.uvprojx, settings and files
target Demo1 (6190000::V6.19::ARMCLANG)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20008FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STSW-L9961BMS_Demo1 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=4
  c define: USE_FULL_ASSERT,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,STM32G071xx,USE_STM32G0XX_NUCLEO,USE_STEVAL_L9961C,USE_L9961_DEMO1,__NO_DOXY
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/l9961;../Drivers/BSP/STEVAL-L99615C;../Drivers/BSP/STM32G0xx_Nucleo
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g071xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c app_bms_com.c app_bms_demo1.c app_bms_demo2.c app_bms_demo3.c app_bms_demo4.c app_bms_utils.c
  group Drivers/BSP/Components/L9961
    ../Drivers/BSP/Components/l9961/: l9961.c l9961_reg.c
  group Drivers/BSP/NUCLEO
    ../Drivers/BSP/STM32G0xx_Nucleo/: stm32g0xx_nucleo.c
  group Drivers/BSP/STEVAL-L99615C
    ../Drivers/BSP/STEVAL-L99615C/: steval_l99615c.c steval_l99615c_bus.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_utils.c
  group Utilities/BatteryStatesEstimation
    ../Utilities/BatteryStatesEstimation/: batterystate.c cellcharact.c
  group Doc
    ../Core/Src/: readme_demo1.txt readme_demo2.txt readme_demo3.txt
target Demo2 (6190000::V6.19::ARMCLANG)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: as above
  output: STSW-L9961BMS_Demo2 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=4
  c define: USE_FULL_ASSERT,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,STM32G071xx,USE_STM32G0XX_NUCLEO,USE_STEVAL_L9961C,USE_L9961_DEMO2,__NO_DOXY
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
target Demo3 (6190000::V6.19::ARMCLANG)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: as above
  output: STSW-L9961BMS_Demo3 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=4
  c define: USE_FULL_ASSERT,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,STM32G071xx,USE_STM32G0XX_NUCLEO,USE_STEVAL_L9961C,USE_L9961_DEMO3,__NO_DOXY
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
target Demo4 (6190000::V6.19::ARMCLANG)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: as above
  output: STSW-L9961BMS_Demo4 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=4
  c define: USE_FULL_ASSERT,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,STM32G071xx,USE_STM32G0XX_NUCLEO,USE_STEVAL_L9961C,USE_L9961_DEMO4,__NO_DOXY
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/l9961;../Drivers/BSP/STEVAL-L99615C;../Drivers/BSP/STM32G0xx_Nucleo;..\Utilities\BatteryStatesEstimation
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
software components: CMSIS:CORE 5.6.0
