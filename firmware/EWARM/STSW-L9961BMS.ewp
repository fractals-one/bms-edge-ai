# IAR project STSW-L9961BMS.ewp, settings and files
configuration STSW-L9961BMS_Demo1 (ARM)
  General.OGChipSelectEditMenu: STM32G071RB ST STM32G071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_ASSERT; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; STM32G071xx; USE_STM32G0XX_NUCLEO; USE_STEVAL_L9961C; USE_L9961_DEMO1; __NO_DOXY
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/Components/l9961; ../Drivers/BSP/STEVAL-L99615C; ../Drivers/BSP/STM32G0xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STSW-L9961BMS_Demo1.bin
  ILINK.IlinkOutputFile: STSW-L9961BMS.out
  ILINK.IlinkIcfFile: stm32g071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STSW-L9961BMS_Demo2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_ASSERT; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; STM32G071xx; USE_STM32G0XX_NUCLEO; USE_STEVAL_L9961C; USE_L9961_DEMO2; __NO_DOXY
  OBJCOPY.OOCOutputFile: STSW-L9961BMS_Demo2.bin
configuration STSW-L9961BMS_Demo3 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_ASSERT; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; STM32G071xx; USE_STM32G0XX_NUCLEO; USE_STEVAL_L9961C; USE_L9961_DEMO3; __NO_DOXY
  OBJCOPY.OOCOutputFile: STSW-L9961BMS_Demo3.bin
configuration STSW-L9961BMS_Demo4 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_ASSERT; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; STM32G071xx; USE_STM32G0XX_NUCLEO; USE_STEVAL_L9961C; USE_L9961_DEMO4; __NO_DOXY
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/Components/l9961; ../Drivers/BSP/STEVAL-L99615C; ../Drivers/BSP/STM32G0xx_Nucleo; ../Utilities/BatteryStatesEstimation
  OBJCOPY.OOCOutputFile: STSW-L9961BMS_Demo4.bin
  group Application/EWARM
    ./: startup_stm32g071xx.s
  group Application/User/Core
    ../Core/Src/: app_bms_com.c app_bms_demo1.c app_bms_demo2.c app_bms_demo3.c app_bms_demo4.c app_bms_utils.c main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Application/User/Core/Inc
    ../Core/Inc/: app_bms_api.h app_bms_com.h app_bms_const.h app_bms_debug.h app_bms_demo1.h app_bms_demo2.h app_bms_demo3.h app_bms_demo4.h app_bms_ocv_conf.h app_bms_test1.h app_bms_utils.h l9961_user_conf.h main.h stm32_assert.h stm32g0xx_hal_conf.h stm32g0xx_it.h
  group Doc
    ../Core/Src/: readme_demo1.txt readme_demo2.txt readme_demo3.txt readme_demo4.txt
  group Drivers/BSP/Components/L9961
    ../Drivers/BSP/Components/L9961/: l9961.c l9961_reg.c
  group Drivers/BSP/STEVAL-L99615C
    ../Drivers/BSP/STEVAL-L99615C/: steval_l99615c.c steval_l99615c_bus.c
  group Drivers/BSP/STM32G0xx_Nucleo
    ../Drivers/BSP/STM32G0xx_Nucleo/: stm32g0xx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_rcc.c stm32g0xx_ll_utils.c
  group Utilities/BatteryStatesEstimation
    ../Utilities/BatteryStatesEstimation/: batterystate.c batterystate.h cellcharact.c cellcharact.h
